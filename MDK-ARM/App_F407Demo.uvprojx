# Keil uVision project App_F407Demo.uvprojx, settings and files
target App_F407Demo (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: App_F407Demo +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Inc;    ../Drivers/STM32F4xx_HAL_Driver/Inc;    ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;    ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;    ../Drivers/CMSIS/Include;    ..\HARDWARE\System;    ..\HARDWARE\key;    ..\HARDWARE\usmart;    ..\HARDWARE\LCD;    ..\HARDWARE\SPI_Flash;    ..\HARDWARE\SDIO;    ..\HARDWARE\FATFS\source
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --keep *.o(.rti_fn.*) --keep *.o(FSymTab)
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User
    ../HARDWARE/: App_Main.c
    ../Src/: main.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_spi.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_sram.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_sd.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group SysTem
    ../HARDWARE/System/: delay.c usart.c
  group Hardware
    ../HARDWARE/key/: key.c
    ../HARDWARE/usmart/: usmart.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/SPI_Flash/: SPI_Flash.c
    ../HARDWARE/SDIO/: sdio_sdcard.c
  group FATFS
    ../HARDWARE/FATFS/source/: diskio.c ff.c ffsystem.c ffunicode.c
software components: CMSIS:CORE 5.1.2, RTOS:kernel 3.1.3, RTOS:shell 3.1.3
